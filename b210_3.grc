options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '50'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '2'
  states: {state: disabled}
- name: df
  id: variable
  parameters:
    value: '-53000'
  states: {}
- name: dp
  id: variable_qtgui_range
  parameters:
    start: '-3'
    step: '.01'
    stop: '3'
    value: '-1'
  states: {}
- name: fdut
  id: variable_qtgui_range
  parameters:
    comment: 5.12334e6
    start: 423.9e6
    step: 1e3
    stop: 439.9e6
    value: 431.9e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: fdut+160*1E6
  states: {}
- name: g1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '75'
    value: '30'
  states: {}
- name: g1
  id: variable
  parameters:
    comment: 868 MHz
    value: '55'
  states: {state: disabled}
- name: g1_0
  id: variable
  parameters:
    comment: 434 MHz
    value: '65'
  states: {}
- name: g2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '75'
    value: '0'
  states: {}
- name: g2
  id: variable
  parameters:
    comment: 868 MHz
    value: '55'
  states: {state: disabled}
- name: g2_0
  id: variable
  parameters:
    comment: 434 MHz
    value: '65'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48000*32*2/6
  states: {}
- name: taps_b210
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '15000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.exp(1j*dp)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: df
    decim: '10'
    samp_rate: samp_rate
    taps: taps_b210
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: df
    decim: '10'
    samp_rate: samp_rate
    taps: taps_b210
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    label1: photodiode
    label2: excitation
    name: B210
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '.5'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    label1: '"Phase"'
    ncols: '5120'
    nrows: '512'
    samp_rate: samp_rate/10
    type: float
    update_time: '.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: int(samp_rate/100)
    srate: samp_rate/10
    type: float
    ylabel: '"Phase"'
    ymax: '3.14'
    ymin: '-3.14'
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    center_freq0: freq-df
    center_freq1: freq-df
    clock_rate: '0.0'
    gain0: g1
    gain1: g2
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
    vlen: N
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_divide_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_interleave_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_interleave_0, '1']
- [blocks_stream_to_vector_0_0, '0', blocks_interleave_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_divide_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', qtgui_freq_sink_x_2, '0']
- [freq_xlating_fir_filter_xxx_0_2, '0', blocks_complex_to_mag_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_2, '0', blocks_divide_xx_0, '1']
- [freq_xlating_fir_filter_xxx_0_2, '0', qtgui_freq_sink_x_2, '1']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [uhd_usrp_source_0_0, '1', freq_xlating_fir_filter_xxx_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
